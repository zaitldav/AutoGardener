# Repository zaitldav/AutoGardener

## KiCad design Indoor_Version/Hardware/Plant_monitoring_device.kicad_pcb

Parts:
C11, C22, C32, C34: 1uF; C0603
C12, C41: 0.1uF; C0603
C21, C31, C33: 10uF; C1210
C35: 10nF; C0603
D1: PPS1045-3G; TO-277-3
D31: MBR230LSFT1G; SOD-123
H1, H2, H3, H4: Mounting_hole_unplated_3,2mm
H111: Mr_Gardener_Logo_Small; mrg_gardener_12mm
J1: Barrel_Jack; BarrelJack_Horizontal
J2: Header_1x6; Header_1x06_P2.54mm
J3, J4, J5, J6, J7, J8, J9, J10: A2501WR-2P1
J11, J12, J13, J14: S3B-ZR
J15: S2B-ZR
L31: 2.2uH; L1210
LD1: RF-W2SA50TS-A39R
Q3, Q4, Q5, Q6, Q7, Q8, Q9, Q10: IRLML6346TRPBF; SOT-23
R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R15, R16, R17, R31: 10k; R0603
R19, R20, R21, R22, R23, R24, R25, R26: 1k; R0603
R32: 49k9; R0603
R33: 15k8; R0603
R111, R112, R113: 150R; R0603
U1: ESP32-WROOM
U2: MCP3424-E_SL; SOIC-14
U3: AOZ1280; SOT-23-6
U4: SHT31

Connections:
+3V3: C11.1, C12.1, C21.1, C22.1, C33.1, C34.1, C41.1, J2.1, J11.2, J12.2, J13.2, J14.2, J15.2, L31.2, R11.1, R12.1, R13.1, R15.2, R17.1, R32.1, U1.2 (VCC), U2.6 (VCC), U4.5 (VDD), U4.7 (R)
+12V: C31.1, C32.1, D1.1 (K), J3.1, J4.1, J5.1, J6.1, J7.1, J8.1, J9.1, J10.1, R31.1, U3.5 (VIN)
/ADC_SOIL1: J11.3, U2.11 (CH3+)
/ADC_SOIL2: J12.3, U2.13 (CH4+)
/ADC_SOIL3: J13.3, U2.1 (CH1+)
/ADC_SOIL4: J14.3, U2.3 (CH2+)
/EN: J2.6, R13.2, U1.3 (EN)
/I2C_SCL: R11.2, U1.29 (IO5), U2.7 (SDA), U4.4 (SCL)
/I2C_SDA: R12.2, U1.28 (IO17), U2.8 (SCL), U4.1 (SDA)
/IO0: J2.5, R17.2, U1.25 (IO0)
/LED_PWM1: R7.1, R23.2, U1.8 (IO32)
/LED_PWM2: R8.1, R24.2, U1.9 (IO33)
/LED_PWM3: R9.1, R25.2, U1.10 (IO25)
/LED_PWM4: R10.1, R26.2, U1.11 (IO26)
/PUMP1: R3.1, R19.2, U1.12 (IO27)
/PUMP2: R4.1, R20.2, U1.13 (IO14)
/PUMP3: R5.1, R21.2, U1.14 (IO12)
/PUMP4: R6.1, R22.2, U1.16 (IO13)
/PWM_LED_B: R113.1, U1.30 (IO18)
/PWM_LED_G: R111.1, U1.33 (IO21)
/PWM_LED_R: R112.1, U1.31 (IO19)
/UART_RX: J2.3, U1.34 (RXD0)
/UART_TX: J2.4, U1.35 (TXD0)
/WATER_LVL_SW: J15.1, U1.26 (IO4)
GND: C11.2, C12.2, C21.2, C22.2, C31.2, C32.2, C33.2, C34.2, C41.2, D31.2 (A), J1.2, J2.2, J11.1, J12.1, J13.1, J14.1, LD1.1 (K), LD1.3 (K), LD1.5 (K), Q3.2 (S), Q4.2 (S), Q5.2 (S), Q6.2 (S), Q7.2 (S), Q8.2 (S), Q9.2 (S), Q10.2 (S), R3.2, R4.2, R5.2, R6.2, R7.2, R8.2, R9.2, R10.2, R16.2, R33.2, U1.1 (GND), U1.15 (GND), U1.38 (GND), U1.39 (GND), U2.2 (CH1-), U2.4 (CH2-), U2.5 (VSS), U2.9 (ADR0), U2.10 (ADR1), U2.12 (CH3-), U2.14 (CH4-), U3.2 (GND), U4.0 (DIE), U4.2 (ADDR), U4.8 (GND)
unnamed: C35.1, U3.1 (BST)
unnamed: C35.2, D31.1 (K), L31.1, U3.6 (LX)
unnamed: D1.2 (A), J1.1
unnamed: J3.2, Q3.3 (D)
unnamed: J4.2, Q4.3 (D)
unnamed: J5.2, Q5.3 (D)
unnamed: J6.2, Q6.3 (D)
unnamed: J7.2, Q7.3 (D)
unnamed: J8.2, Q8.3 (D)
unnamed: J9.2, Q9.3 (D)
unnamed: J10.2, Q10.3 (D)
unnamed: LD1.2 (A), R111.2
unnamed: LD1.4 (A), R112.2
unnamed: LD1.6 (A), R113.2
unnamed: Q3.1 (G), R19.1
unnamed: Q4.1 (G), R20.1
unnamed: Q5.1 (G), R21.1
unnamed: Q6.1 (G), R22.1
unnamed: Q7.1 (G), R23.1
unnamed: Q8.1 (G), R24.1
unnamed: Q9.1 (G), R25.1
unnamed: Q10.1 (G), R26.1
unnamed: R15.1, U1.23 (IO15)
unnamed: R16.1, U1.24 (IO2)
unnamed: R31.2, U3.4 (EN)
unnamed: R32.2, R33.1, U3.3 (FB)

Notes on the sheet:
tantal
Debug Log Print Active

Board: 2 copper layers, 79.0 x 79.0 mm, 74 parts (1 on the bottom side), 51 nets.

## KiCad design Outdoor_Version/Hardware/AutoGardener_Outdoor.kicad_pcb

Board: 2 copper layers, 22.0 x 30.0 mm, 24 parts (1 on the bottom side), 17 nets.

Parts:
BAT1: Battery; Header_1x02_P2.54mm
C1, C5, C7: 1uF; C0603
C2, C3: 0.1uF; C0603
C4, C6: 10uF; C0603
H1, H2: Mounting_hole_unplated_3,2mm
H111: Mr_Gardener_Logo_Small; mrg_gardener_08mm
J1: SWO; Header_1x05_P2.54mm
J2, J3: Header_1x3; Header_1x03_P2.54mm
J4: Header_1x2; Header_1x02_P2.54mm
LD3: ORANGE; LED_0805
LD13: RED; LED_0805
Q1, Q2: 2N7002P.215; SOT-23
R1: 10k; R0603
R2, R3: 1k; R0603
U1: STM32L031K6T6; LQFP-32_7x7mm_P0.8mm
U2: AP2204RB-3.3TRG1; SOT-89

Connections:
+5V: BAT1.1, C4.1, C5.1, J4.1, U2.3
/ADC_SOIL1: J3.3, U1.7
/BAT_LO: R2.1, U1.10
/LED1: R3.1, U1.9
/NRST: J1.5, U1.4
/OUT1: Q2.1, U1.8
/SENS_ENA: Q1.1, R1.1, U1.25
/SWCLK: J1.2, U1.24
/SWDIO: J1.4, U1.23
/UART_RX: J2.1, U1.20
/UART_TX: J2.2, U1.19
GND: BAT1.2, C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, J1.3, J2.3, LD3.1, LD13.1, Q1.2, Q2.2, R1.2, U1.16, U1.31, U1.32, U2.2
unnamed: J3.1, Q1.3
unnamed: J4.2, Q2.3
unnamed: LD3.2, R3.2
unnamed: LD13.2, R2.2
VCC: C1.1, C2.1, C3.1, C6.1, C7.1, J1.1, J3.2, U1.1, U1.5, U1.6, U1.17, U2.1

## KiCad design Hardware/Plant_monitoring_device.kicad_pcb

Parts:
A1: Antenna; ANT_WIRE_THT
BAT1: Battery; BatteryHolder_Keystone_2468_2xAAA
C11, C21, C32, C34: 1uF; C0603
C12, C13, C22, C41: 0.1uF; C0603
C31, C33: 10uF; C0603
H1, H2, H3: Mounting_hole_unplated_3,2mm
J1: Barrel_Jack; BarrelJack_Horizontal
J2: SWO; Header_1x05_P2.54mm
J3, J4, J5, J6, J7, J8, J9, J10: NXW-02
J11, J12, J13, J14: NXW-03
LD3, LD4, LD5, LD6: RED; LED_0805
LD13: ORANGE; LED_0805
Q1, Q2: FDN308P; SOT-23
Q3, Q4, Q5, Q6, Q7, Q8, Q9, Q10: IRLML6346TRPBF; SOT-23
R1, R2, R7, R8, R9, R10, R41, R42: 10k; R0603
R3, R4, R5, R6, R13: 1k; R0603
SB1, SB2, SB3, SB4, SB5, SB6: SolderBridge; SB0603
U1: STM32L031K6T6; LQFP-32_7x7mm_P0.8mm
U2: RN2483A
U3: AP2204RB-3.3TRG1; SOT-89
U4: SHT31

Connections:
+12V: C31.1, C32.1, J1.1, J3.1, J4.1, J5.1, J6.1, J7.1, J8.1, J9.1, J10.1, SB2.1, U3.3 (VIN)
/ADC_SOIL1: J11.2, U1.7
/ADC_SOIL2: J12.2, U1.8
/ADC_SOIL3: J13.2, U1.9
/ADC_SOIL4: J14.2, U1.10
/BAT_LO: R13.1, U1.18
/COMM_ENA: Q2.1 (G), R2.2, U1.28
/I2C_SCL: R41.2, U1.29, U4.4 (SCL)
/I2C_SDA: R42.2, U1.30, U4.1 (SDA)
/LED_PWM1: Q7.1 (G), R7.1, U1.11
/LED_PWM2: Q8.1 (G), R8.1, U1.12
/LED_PWM3: Q9.1 (G), R9.1, U1.13
/LED_PWM4: Q10.1 (G), R10.1, U1.14
/LORA_nRESET: U2.32 (nRESET)
/NRST: J2.5, U1.4
/OUT1: R3.1, SB3.1, U1.27
/OUT2: R4.1, SB4.1, U1.26
/OUT3: R5.1, SB5.1, U1.25
/OUT4: R6.1, SB6.1, U1.22
/PA11: U1.21
/PF0: U1.2
/PF1: U1.3
/SENS_ENA: Q1.1 (G), R1.2, U1.15
/SWCLK: J2.2, U1.24
/SWDIO: J2.4, U1.23
/UART_RX: U1.20, U2.6 (UART_TX)
/UART_TX: U1.19, U2.7 (UART_RX)
GND: BAT1.2 (-), C11.2, C12.2, C13.2, C21.2, C22.2, C31.2, C32.2, C33.2, C34.2, C41.2, J1.2, J2.3, J11.3, J12.3, J13.3, J14.3, LD3.1 (K), LD4.1 (K), LD5.1 (K), LD6.1 (K), LD13.1 (K), Q3.2 (S), Q4.2 (S), Q5.2 (S), Q6.2 (S), Q7.2 (S), Q8.2 (S), Q9.2 (S), Q10.2 (S), R7.2, R8.2, R9.2, R10.2, U1.16, U1.31, U1.32, U2.1 (GND), U2.8 (GND), U2.11 (GND), U2.20 (GND), U2.21 (GND), U2.22 (GND), U2.24 (GND), U2.26 (GND), U2.27 (GND), U2.28 (GND), U2.33 (GND), U2.41 (GND), U2.47 (GND), U3.2 (GND), U4.0 (DIE), U4.2 (ADDR), U4.8 (GND)
unnamed: A1.1, U2.23 (RFH)
unnamed: J3.2, Q3.3 (D)
unnamed: J4.2, Q4.3 (D)
unnamed: J5.2, Q5.3 (D)
unnamed: J6.2, Q6.3 (D)
unnamed: J7.2, Q7.3 (D)
unnamed: J8.2, Q8.3 (D)
unnamed: J9.2, Q9.3 (D)
unnamed: J10.2, Q10.3 (D)
unnamed: LD3.2 (A), R3.2
unnamed: LD4.2 (A), R4.2
unnamed: LD5.2 (A), R5.2
unnamed: LD6.2 (A), R6.2
unnamed: LD13.2 (A), R13.2
unnamed: Q3.1 (G), SB3.2
unnamed: Q4.1 (G), SB4.2
unnamed: Q5.1 (G), SB5.2
unnamed: Q6.1 (G), SB6.2
VCC: BAT1.1 (+), C11.1, C12.1, C13.1, C33.1, C34.1, J2.1, Q1.3 (D), Q2.3 (D), R1.1, R2.1, SB1.1, SB2.2, U1.1, U1.5, U1.6, U1.17, U3.1 (VOUT)
VDD: C21.1, C22.1, Q2.2 (S), U2.12 (VDD), U2.34 (VDD)
VDDA: C41.1, J11.1, J12.1, J13.1, J14.1, Q1.2 (S), R41.1, R42.1, SB1.2, U4.5 (VDD), U4.7 (R)

Notes on the sheet:
SOIL1 DRY
SOIL2 DRY
SOIL3 DRY
SOIL4 DRY
BAT LOW
LoRa Module
VDD
VDDA
VDDIO
3V3
2x AAA
50 Ohm
VCC - Power for MCU VDD - Power for LoRa VDDA - Power for Sensors

Board: 2 copper layers, 75.0 x 55.0 mm, 67 parts (1 on the bottom side), 45 nets.

## Code that names these connections

File Firmware/Inc/main.h:

/* USER CODE BEGIN Header */
/**
  ******************************************************************************
  * @file           : main.h
  * @brief          : Header for main.c file.
  *                   This file contains the common defines of the application.
  ******************************************************************************
  * @attention
  *
  * <h2><center>&copy; Copyright (c) 2019 STMicroelectronics.
  * All rights reserved.</center></h2>
  *
  * This software component is licensed by ST under BSD 3-Clause license,
  * the "License"; You may not use this file except in compliance with the
  * License. You may obtain a copy of the License at:
  *                        opensource.org/licenses/BSD-3-Clause
  *
  ******************************************************************************
  */
/* USER CODE END Header */

/* Define to prevent recursive inclusion -------------------------------------*/
#ifndef __MAIN_H
#define __MAIN_H

#ifdef __cplusplus
extern "C" {
#endif

/* Includes ------------------------------------------------------------------*/
#include "stm32l0xx_hal.h"

/* Private includes ----------------------------------------------------------*/
/* USER CODE BEGIN Includes */

/* USER CODE END Includes */

/* Exported types ------------------------------------------------------------*/
/* USER CODE BEGIN ET */

/* USER CODE END ET */

/* Exported constants --------------------------------------------------------*/
/* USER CODE BEGIN EC */

/* USER CODE END EC */

/* Exported macro ------------------------------------------------------------*/
/* USER CODE BEGIN EM */

/* USER CODE END EM */

void HAL_TIM_MspPostInit(TIM_HandleTypeDef *htim);

/* Exported functions prototypes ---------------------------------------------*/
void Error_Handler(void);

/* USER CODE BEGIN EFP */

/* USER CODE END EFP */

/* Private defines -----------------------------------------------------------*/
#define ADC_BAT_Pin GPIO_PIN_0
#define ADC_BAT_GPIO_Port GPIOA
#define ADS_SOIL1_Pin GPIO_PIN_1
#define ADS_SOIL1_GPIO_Port GPIOA
#define ADC_SOIL2_Pin GPIO_PIN_2
#define ADC_SOIL2_GPIO_Port GPIOA
#define ADC_SOIL3_Pin GPIO_PIN_3
#define ADC_SOIL3_GPIO_Port GPIOA
#define ADC_SOIL4_Pin GPIO_PIN_4
#define ADC_SOIL4_GPIO_Port GPIOA
#define PWM_LED1_Pin GPIO_PIN_5
#define PWM_LED1_GPIO_Port GPIOA
#define PWM_LED2_Pin GPIO_PIN_6
#define PWM_LED2_GPIO_Port GPIOA
#define PWM_LED3_Pin GPIO_PIN_7
#define PWM_LED3_GPIO_Port GPIOA
#define PWM_LED4_Pin GPIO_PIN_0
#define PWM_LED4_GPIO_Port GPIOB
#define SENS_ENA_Pin GPIO_PIN_1
#define SENS_ENA_GPIO_Port GPIOB
#define BAT_LO_Pin GPIO_PIN_8
#define BAT_LO_GPIO_Port GPIOA
#define OUT4_Pin GPIO_PIN_12
#define OUT4_GPIO_Port GPIOA
#define OUT3_Pin GPIO_PIN_15
#define OUT3_GPIO_Port GPIOA
#define OUT2_Pin GPIO_PIN_3
#define OUT2_GPIO_Port GPIOB
#define OUT1_Pin GPIO_PIN_4
#define OUT1_GPIO_Port GPIOB
#define COMM_ENA_Pin GPIO_PIN_5
#define COMM_ENA_GPIO_Port GPIOB
/* USER CODE BEGIN Private defines */

/* USER CODE END Private defines */

#ifdef __cplusplus
}
#endif

#endif /* __MAIN_H */

/************************ (C) COPYRIGHT STMicroelectronics *****END OF FILE****/

## Commit log

2019-04-08 Initial commit with KiCAD files.
2019-04-08 Changes Step-down for LDO.
2019-04-10 Changes 2.54mm headers for 2mm connectors. Added a solderbridge to connect external supply with the mcu suply (so the outpust and pwms coul be used when the device is powered by a battery. Changed la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
2019-04-11 Swapped some pins to optmize track to tranzistors. Generated Gerbers.
2019-04-11 Created CubeMX Project.
2019-04-11 Created .gitignore
2019-04-11 Generated gerbers and created layer description.
2019-04-11 Minor edits in CubeMX project.
2019-04-11 Added dimensions.
2019-04-11 Added missing TME Symbols. Generated BOM.
2019-05-14 Connected BOOT0 pin with GND.
2019-05-14 Created Project using STM32CubeIDE.
2019-05-14 Created Enclosure Prototype.
2019-05-28 Created a box for the moisture sensor.
2019-05-28 Measured the threshold for watering and set it accordingly. Changed the watering and idle periods.
2019-05-28 Edited the box a bit after the first 3D print.
2019-06-06 Moved existing files to a new folder Prototype. Copied these files to separate folders for indoor and outdoor version
2019-06-06 Renamed the CubeMX project.
2019-06-06 Edited the schematic to fit the outdoor one valve, one sensor application. Started routing the PCB.
2019-07-09 Small changes on the prototype firmware.
2019-07-09 Generated the STM32 firmware project.
2019-07-09 Started a new kicad project.
2019-07-09 Replaced STM32 with ESP32. Deleted the PCB.
2019-07-10 Created outline of the PCB and basic layout of connectors. Created schematic and PCB layout of the buck convertor.
2019-07-19 Created a logo for the project
2019-07-19 Finished design of the indoor version of the gardener. Generated gerbers.
2019-07-19 Finished the design of the outdoor version of the gardener. Generated Gerbers.
2019-08-12 Added some mechanical details into the PCB document.
2019-08-12 Minor changes.
2019-08-12 Started to work on the box design.
2019-08-13 Merging.
2019-11-17 Added holes for connector in the box.
2019-11-17 Cache save.
2019-11-17 Deleted files for STM32 and created a project for ESP32 using Platformio.
2019-11-17 Just some change in the project settings. ADD GITIGNORE TO GET RID OF BULLSHIT LIKE THIS.
2019-11-17 Generated BOM.
2019-11-17 Looks like a minor recompile. IDK
